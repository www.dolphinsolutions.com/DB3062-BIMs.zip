Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2020-01-06T15:56:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.11200.0000 - Exporter 18.0.0.412 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 06 15:56:30 2020 * Host: ANDYHOUSE * Database: C:\Users\ANDY~1.HOU\AppData\Local\Temp\{560C20A2-82AF-4317-BC30-E15FFA9E4946}\ifc * Database version: 5507 * Database creation date: Mon Jan 06 15:56:28 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 06 15:56:29 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 06 15:56:29 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: Standard, Family1:Standard:201763
In: Level 1
Type - Material: 192_192_192, 255_0_0
Type - Identity Data - Description: Wall Mounted Shower Arm 200 long; Manufacturer: Dolphin Solutions Limited; Model: DB3062.200; Type Name: Standard; URL: https://www.dolphinsolutions.co.uk/en/
Type - Other - Category: Generic Models; Family Name: Family1
Pset_BuildingElementProxyCommon - Reference: Standard
Pset_ManufacturerTypeInformation - Manufacturer: Dolphin Solutions Limited
Constraints - Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0209066 m2; Volume: 0.0000326774 m3
Other - Family: Family1: Standard; Family and Type: Family1: Standard; Type: Family1: Standard; Type Id: Family1: Standard
Phasing - Phase Created: New Construction
